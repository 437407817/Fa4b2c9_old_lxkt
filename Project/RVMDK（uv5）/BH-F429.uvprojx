# Keil uVision project BH-F429.uvprojx, settings and files
target STM32F429 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429 +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1
  c define: MBEDTLS_CONFIG_FILE=<mbedtls_config_sha_x.h>,USE_STDPERIPH_DRIVER,STM32F429_439xx,
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\FreeRTOS;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\User\mbedtls-3.6\include\;..\..\User\mbedtls-3.6\configs;..\..\User\mbedtls-3.6\library;..\..\User\crypt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS
    ../../FreeRTOS/: freerotspro.c
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group SeggerRTT
    ../../User/SeggerRTT/: SEGGER_RTT_printf.c SEGGER_RTT.c SEGGER_TOOLKIT.c SEGGER_dao.c SEGGER_OutInterface.c
  group USER
    ../../User/led/: bsp_led.c
    ../../User/usart/: bsp_usart.c rx_data_queue.c bsp_485_usart.c p_data_queue.c bsp_usart_sd.c usart485verify.c queue2.c
    ../../User/i2c/hard_i2c/: bsp_i2c_ee.c bsp_iic.c
    ../../User/i2c/soft_i2c/: bsp_soft_i2c_ee.c bsp_soft_i2c_gpio.c
    ../../User/adc/: bsp_adc.c ADS7822.c CC6902.c
    ../../User/spi/: bsp_spi.c
    ../../User/spi/flash/: bsp_spi_flash.c
    ../../User/io/IN_io/: bsp_gpio_in.c
    ../../User/io/OUT_io/: bsp_gpio_out.c
    ../../User/can/: bsp_can.c
    ../../User/sdram/: bsp_sdram.c
    ../../User/sensor/: DS1302.c
    ../../User/dac/: DAC7311.c
    ../../User/iwdg/: bsp_iwdg.c
    ../../User/power/: bsp_power.c
    ../../User/i2c/: factory_iic.c
  group TM
    ../../User/TM/: tm_stm32f4_gpio.c tm_stm32f4_usart.c tm_stm32f4_spi.c
  group MAIN
    ../../User/: main.c stm32f4xx_it.c stm32fxxx.h defines.h GV_variable.c system_config.h
    ../../User/sys/: sys_init_all.c
  group TEST
    ../../User/test/: bsp_test_all.c bsp_test_SeggerRTT.c bsp_test_usart.c bsp_test_iic.c bsp_test_adc.c bsp_test_spi.c bsp_test_can.c bsp_test_gpio_in.c bsp_test_gpio_out.c bsp_test_soft_iic.c bsp_test_485.c bsp_test_sdram.c pro_test.c pro_test.h
    ../../User/sensor/: bsp_test_DS1302.c
  group CONFIG
    ../../FreeRTOS/: FreeRTOSConfig.h
  group Controller
    ../../User/controller/: DisStateFun.c StateFun.c MainWorkFun.c MainWorkFun.h TaskFun.c TaskSingleWork.c TaskSingleWork.h TaskFun_Outer.c TaskFun_Outer.h
  group SYSTEM
    ../../User/sys/: bsp_systime.c bsp_random.c systick.c systick.h sys_interrupt.c
    ../../User/malloc/: malloc.c
  group DOC
    ../../: 必读说明.txt
  group Converter
    ../../User/converter/: ADCfilter.c data_convert.c data_math.c data_sort.c cvt_time.c cvt_time.h data_compare.c data_find.c data_find.h
  group screen
    ../../User/screen/: Screen.c ScreenDataDis.c ScreenSendFun.c ScreenDataDis.h ScreenDS1302.c
  group Service
    ../../User/service/: EepromFun.c ModeWorkFun.c ModeWorkFun.h DisposeDataFun.c DisposeDataFun.h CapacityFun.c CapacityFun.h PowerDownFun.c Workled.c StopMechineFun.c StopMechineFun.h StartMechineFun.c StandbyMechineFun.c ActiveMechineFun.c CanFun.c
  group communication
    ../../User/communication/: Comu485.c Comu485Dis.c Comu485DataFun.c Comu485DataFun.h SD_485Dis.c SD_485DataFun.c SD_485DataFun.h
  group mbedtls-3.6
    ../../User/mbedtls-3.6/library/: aes.c chacha20.c chachapoly.c cipher.c cipher_wrap.c constant_time.c gcm.c platform.c platform_util.c poly1305.c threading.c
    ../../User/mbedtls-3.6/configs/: mbedtls_config_sha_x.h
  group crypt
    ../../User/crypt/: bsp_encode.c crypt_aes.c crypt_aes_test.c chipID_dis.c
